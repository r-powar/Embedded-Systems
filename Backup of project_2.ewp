# IAR project Backup of project_2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S8962 TexasInstruments LM3S8962
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: ewarm; PART_LM3S8962
  ICCARM.CCIncludePath2: C:\StellarisWare; ..; ..\..\..; ..\..; $PROJ_DIR$
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkAdditionalLibs: ..\..\..\driverlib\ewarm-cm3\Exe\driverlib-cm3.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../../../Users/Raj/Desktop/Embedded Systems/project2_update/: BoolInclude.h
    ./: compute.c compute.h display.c display.h GlobalCounter.c GlobalCounter.h main.c measure.c measure.h ProjectStructs.h startup_ewarm.c statusMethod.c statusMethod.h TCB.h warning.c warning.h
    ../drivers/: rit128x96x4.c
    ../../../utils/: ustdlib.c

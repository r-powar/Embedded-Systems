# IAR project project_2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S8962 TexasInstruments LM3S8962
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: C:\StellarisWare; ..; ..\..\..; ..\..; $PROJ_DIR$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../../../Users/Raj/Desktop/Embedded Systems/project2_update/: BoolInclude.h compute.c compute.h display.c display.h measure.c measure.h statusMethod.c statusMethod.h TCB.h warning.c warning.h
    ../../../driverlib/ewarm-cm3/Exe/: driverlib-cm3.a
    ./: main.c ProjectStructs.h
    ../drivers/: rit128x96x4.c
    ../hello/: startup_ewarm.c
    ../../../utils/: ustdlib.c
